
#20220131
PACKAGECONFIG:append = " amrnb amrwb cdio dvdread x264"
