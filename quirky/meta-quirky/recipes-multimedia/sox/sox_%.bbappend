
#20211219
PACKAGECONFIG += " wavpack flac amrwb amrnb oggvorbis mad id3tag lame ao"

SUMMARY = "SoX is the Swiss Army knife of sound processing tools"
