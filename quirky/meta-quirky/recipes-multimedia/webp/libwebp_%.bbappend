
#DEPENDS = "giflib zlib jpeg tiff libpng libsdl libsdl-image mesa"
#2020-09-16 think only going to have libsdl2...
DEPENDS = "giflib zlib jpeg tiff libpng mesa"
