
##remove 'avahi'
#DEPENDS = "libsoup-2.4 webkitgtk gtk+3 iso-codes libnotify gcr 
#	   gsettings-desktop-schemas libxml2-native 
#	   glib-2.0 glib-2.0-native json-glib libdazzle libhandy 
#	   nettle libarchive coreutils-native"

DEPENDS:remove = "avahi"
