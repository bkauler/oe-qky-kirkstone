
#20221203
REQUIRED_DISTRO_FEATURES:remove = "polkit"
#colord also needs polkit which apparently cannot be removed...
DEPENDS:remove = "colord"
