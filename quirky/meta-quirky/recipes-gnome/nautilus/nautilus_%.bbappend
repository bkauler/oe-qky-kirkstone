
#20221203 gnome-desktop requires gtk4 and a later pango
DEPENDS:remove = "gnome-desktop"
#have brought gnome-desktop3 from honister...
DEPENDS:append = " gnome-desktop3"
