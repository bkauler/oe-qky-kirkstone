
#20221203 gnome-desktop requires gtk4 and a later pango
DEPENDS:remove = "gnome-desktop"
