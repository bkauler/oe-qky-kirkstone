
PACKAGECONFIG = "ares brotli icu zlib"

DEPENDS:append:class-target = " nghttp2 libuv"
