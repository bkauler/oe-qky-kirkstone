
#20221206
RPROVIDES:clang:append = " llvm llvm-locale llvm-libllvm llvm-liboptremarks \
    llvm-staticdev llvm-dev llvm-src llvm-dbg llvm-bugpointpasses \
    llvm-liblto llvm-doc llvm-llvmhello"
