
#20240315
EXTRA_OECONF:append = " --enable-static"
