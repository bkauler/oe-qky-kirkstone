

# BK add graphite2 
DEPENDS = "glib-2.0 cairo fontconfig freetype graphite2"

PACKAGECONFIG:append = " graphite"
