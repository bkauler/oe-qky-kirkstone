
#20221204
DEPENDS += "libxslt libpng libx11 boost litehtml jpeg cairo \
           libxml2 zlib gtk+3 virtual/libintl \
           enchant2 aspell libsigc++-2.0 gtksourceview2 \
           intltool glibmm libart-lgpl librsvg librsvg-native popt cups \
           ghostscript freetype fontconfig \
           wget libcanberra gdl libpng \
           libwpd readline gzip libxext libice"

