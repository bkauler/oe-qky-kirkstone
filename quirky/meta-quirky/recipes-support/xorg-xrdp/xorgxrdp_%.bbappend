
REQUIRED_DISTRO_FEATURES = "x11"
