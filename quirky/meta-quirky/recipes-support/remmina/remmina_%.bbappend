
#DEPENDS = "openssl freerdp gtk+3 gdk-pixbuf atk libgcrypt libsodium \
#           libssh vte json-glib libsoup-2.4 libvncserver libsecret libxkbfile"

PACKAGECONFIG = ""

#EXTRA_OECMAKE += "-DWITH_AVAHI=OFF"
