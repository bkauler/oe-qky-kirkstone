
PACKAGECONFIG:append = " lz4 lzma zlib"
